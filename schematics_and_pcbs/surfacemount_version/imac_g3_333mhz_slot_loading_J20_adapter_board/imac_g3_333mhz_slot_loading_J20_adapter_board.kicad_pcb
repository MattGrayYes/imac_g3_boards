# Repository MattGrayYes/imac_g3_boards

## KiCad design schematics_and_pcbs/surfacemount_version/imac_g3_333mhz_slot_loading_J20_adapter_board/imac_g3_333mhz_slot_loading_J20_adapter_board.kicad_pcb

Board: 2 copper layers, 82.5 x 52.5 mm, 41 parts (3 on the bottom side), 44 nets.

Parts:
C1, C2: 22pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C4, C5, C6: 100uF 6.3V; CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder
C7, C9, C10, C11, C12: .1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2, D3: D_Schottky_ALT; D_SOD-123
H1, H2: MountingHole_Pad; MountingHole_3.5mm_Pad
J1: Screw_Terminal_01x06; TerminalBlock_Phoenix_PT-1,5-6-5.0-H_1x06_P5.00mm_Horizontal
J2: Conn_02x10_Odd_Even; PinHeader_2x10_P2.54mm_Vertical
J3, J5: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J4: DE15_Receptacle_HighDensity_MountingHoles; DSUB-15-HD_Female_Horizontal_P2.29x1.98mm_EdgePinOffset8.35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
J6: USB_C_Receptacle_USB2.0; USB_C_Receptacle_G-Switch_GT-USB-7010ASV
JP1: SolderJumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
JP2, JP3, JP4, JP5: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1, R2, R3, R6, R7: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R5, R8: 5.1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R9, R10: 27; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm
U2: TS5A23159DGS; VSSOP-10_3x3mm_P0.5mm
U3: FT231XS; SSOP-20_3.9x8.7mm_P0.635mm
Y1: 16 Mz cystal; Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering

Connections:
/5V_TRICKLE: D1.2 (A), J2.6
/5V_USB: D3.2 (A), J6.A4 (VBUS), J6.A9 (VBUS), J6.B4 (VBUS), J6.B9 (VBUS)
/+5V_BOARD: C3.1, C4.1, C5.1, C6.1, C9.1, C10.1, C11.1, C12.1, D1.1 (K), D2.1 (K), D3.1 (K), J3.2, R1.2, R3.1, U1.4 (VCC), U1.6 (VCC), U1.18 (AVCC), U2.2, U2.4, U2.8 (VCC), U3.14 (~RESET), U3.15 (VCC)
/-10V: J1.3, J2.8
/BLUE: J2.13, J4.3
/COMPUTER_5V: D2.2 (A), J4.9
/COMPUTER_SCL: J4.15, J5.2, U1.28 (PC5)
/COMPUTER_SDA: J4.12, J5.1, U1.27 (PC4)
/DCO: J1.5, J2.5
/GREEN: J2.15, J4.2
/H_SYNC: J2.9, J4.13
/IVAD_SCL: J2.2, U1.9 (PD5)
/IVAD_SDA: J2.1, U1.2 (PD4)
/LINE_SENSE: J1.2, J2.19
/LPIACT:L1_LP: J2.10, J2.12, U2.10
/MISO: J3.1, U1.16 (PB4)
/MOSI: J3.4, U1.15 (PB3)
/PB0: J5.4, U1.12 (PB0)
/PB1: J5.6, U1.13 (PB1)
/PROT: J1.4, J2.7, R2.2
/PWR_BTN: J1.1, R1.1, U1.1 (PD3)
/PWR_LED: J1.6, U2.6
/RED: J2.17, J4.1
/SCK: J3.3, U1.17 (PB5)
/SERIAL_RX: J5.3, JP4.1 (A), U1.30 (PD0)
/SERIAL_TX: JP5.1 (A), R7.1, R8.1, U1.31 (PD1)
/V_SYNC: J2.11, J4.14, JP3.2 (B)
/~RESET: C7.2, J3.5, R3.2, U1.29 (~RESET/PC6)
GND: C1.1, C2.2, C3.2, C4.2, C5.2, C6.2, C9.2, C10.2, C11.2, C12.2, H1.1, H2.1, J2.3, J2.4, J2.14, J2.16, J2.18, J2.20, J3.6, J4.0, J4.5, J4.6, J4.7, J4.8, J4.10, J6.A1 (GND), J6.A12 (GND), J6.B1 (GND), J6.B12 (GND), J6.S1 (SHIELD), R2.1, R4.2, R5.2, R6.1, R8.2, U1.3 (GND), U1.5 (GND), U1.21 (GND), U2.3 (GND), U2.7, U2.9, U3.6 (GND), U3.16 (GND), Y1.2, Y1.4
unnamed: J5.5, R7.2
unnamed: J6.A5 (CC1), R5.1
unnamed: J6.B5 (CC2), R4.1
unnamed: J6.A6 (D+), J6.B6 (D+), R10.1
unnamed: J6.A7 (D-), J6.B7 (D-), R9.1
unnamed: C7.1, JP1.1 (A), JP2.1 (A)
unnamed: JP1.2 (B), JP2.2 (B), U3.1 (~DTR)
unnamed: JP3.1 (A), U1.14 (PB2)
unnamed: JP4.2 (B), U3.20 (TXD)
unnamed: JP5.2 (B), U3.4 (RXD)
unnamed: R6.2, U1.11 (PD7), U2.1, U2.5
unnamed: C1.2, U1.7 (XTAL1/PB6), Y1.1
unnamed: C2.1, U1.8 (XTAL2/PB7), Y1.3
unnamed: R9.2, U3.12 (USBDM)
unnamed: R10.2, U3.11 (USBDP)

## KiCad design schematics_and_pcbs/imac_g3_slot_loading_J22_adapter_board/imac_g3_slot_loading_J22_adapter_board.kicad_pcb

Board: 2 copper layers, 65.0 x 30.0 mm, 12 parts (4 on the bottom side), 23 nets.

Parts:
C1: 1uF; CP_Radial_D4.0mm_P1.50mm
H1: MountingHole_Pad; MountingHole_3.5mm_Pad
J1: Conn_02x13_Odd_Even; PinHeader_2x13_P2.54mm_Vertical
J2: Screw_Terminal_01x10; TerminalBlock_Phoenix_PT-1,5-10-5.0-H_1x10_P5.00mm_Horizont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
J3: AudioJack3; Jack_3.5mm_CUI_SJ1-3533NG_Horizontal_CircularHoles
J4: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
JP1, JP3: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
R1, R2: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 2.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal

Connections:
/+AC: J1.24, J1.26, J2.1
/+AMBER_LED: J1.20, R2.2
/+GREEN_LED: J1.19, JP3.1, R1.2
/+LEFT_SPEAKER: J1.14, J2.8
/+MICROPHONE: J1.3, JP2.2
/+RIGHT_SPEAKER: J1.13, J2.10
/-AC: J1.23, J1.25, J2.2
/-LEFT_SPEAKER: J1.16, J2.7
/-RIGHT_SPEAKER: J1.15, J2.9
/HEADPHONE_1_LEFT: J1.10, J4.6
/HEADPHONE_1_RIGHT: J1.9, J4.5
/HEADPHONE_1_SENSE: J1.8, J4.4
/HEADPHONE_2_LEFT: J1.6, J4.2
/HEADPHONE_2_RIGHT: J1.5, J4.1
/HEADPHONE_2_SENSE: J1.7, J4.3
/MICROPHONE_POWER: J3.R, JP3.2, R3.2
/POWER_BUTTON: J1.17, J2.4
GNDREF: H1.1, J1.1, J1.2, J1.4, J1.11, J1.18, J2.6, J3.S
unnamed: C1.1, J3.T, JP2.3
unnamed: C1.2, JP1.2, JP2.1
unnamed: J2.3, R1.1
unnamed: J2.5, R2.1
unnamed: JP1.1, R3.1

## KiCad design schematics_and_pcbs/imac_g3_down_converter_board_adapter/imac_g3_down_converter_board_adapter.kicad_pcb

Board: 2 copper layers, 88.0 x 39.0 mm, 8 parts (0 on the bottom side), 13 nets.

Parts:
H1: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J1: Screw_Terminal_01x10; TerminalBlock_Phoenix_PT-1,5-10-5.0-H_1x10_P5.00mm_Horizont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
J2: Screw_Terminal_01x04; TerminalBlock_Phoenix_PT-1,5-4-5.0-H_1x04_P5.00mm_Horizontal
J7: Conn_02x12_Top_Bottom; Molex_Micro-Fit_3.0_43045-2400_2x12_P3.00mm_Horizontal
JP1: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
M1: Fan_Tacho_PWM; FanPinHeader_1x04_P2.54mm_Vertical
TP1, TP2: TestPoint; TestPoint_Plated_Hole_D2.0mm

Connections:
/+3.3V: J1.7, J1.8, J7.1, J7.18, J7.19, J7.20, J7.21
/+5V: J1.5, J1.6, J7.14, J7.15, J7.24, JP1.3
/+8V_STANDBY_+12V_ON: J1.9, J7.22
/+12V: J1.3, J1.4, J7.13, JP1.1
/+15V_STANDBY_+24V_ON: J1.10, J7.12
/+AC: J2.4, J7.10, J7.11
/-AC: J2.3, J7.8, J7.9
/DCO: J2.1, J7.5
/GND: H1.1, J1.1, J1.2, J7.2, J7.3, J7.6, J7.7, J7.16, J7.17, J7.23, M1.1
/PT: J2.2, J7.4
/PWM: M1.4, TP2.1
/TACHO: M1.3, TP1.1
unnamed: JP1.2, M1.2

## Commit log

2025-07-09 Tidied up some code, changed values to work on my surface mount PCB and iMac Slot Loader, added new EDID.
    * Added new EDID, an edit of edid6 from oshimai to display "iMac G3 CRT" as the screen name
    * Added Copy/pasteable versions of edids as hex and base64
    * Changed BUFFER_LENGTH instructions to include MacOS path and an #ifndef, so the buffers are still 32 by default
    Added BUFFER_LENGTH check at compile
    * From [shuuryou's comment on issue 11](https://github.com/qbancoffee/imac_g3_ivad_board_init/issues/11#issuecomment-988259400)
    * Removed monitor property values as these variables never get updated
2025-07-09 graffittied silkscreens.
